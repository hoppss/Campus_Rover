Commit message: add arm action service & test work

File: coover_arm/coover_arm_description/urdf/coover_arm.urdf (robot description, URDF)
Before this commit: robot coover_arm, 7 links, 6 joints
Joints:
- joint joint_5: origin xyz=0 0 0.048 rpy=0 0 0 -> xyz=0 0 0.048 rpy=0 -1.57 0
